Commit message: [add/del] assets

File: resources/models/environment_assets/balls/ball/model.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link ball: mass 0.0 -> 0.3; geometry collision sphere radius=0.2; visual sphere radius=0.2
